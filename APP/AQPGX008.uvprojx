# Keil uVision project AQPGX008.uvprojx, settings and files
target AQW1801 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: AQPGX008 +hex
  AfterMake: fromelf.exe --bin --output ./DEBUG/BIN/@L.bin ./DEBUG/OBJ/@L.axf
  AfterMake: .\DEBUG\hexmove.bat
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c misc: --gnu
  c include: .\CORE;.\FWLib\inc;.\USER;.\TYWIFI;.\INSIDELIB;.\USER\TUYA;.\USER\FUNC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CORE
    ./CORE/: stm32f0xx_it.c system_stm32f0xx.c startup_stm32f030x8.s
  group FWLib
    ./FWLib/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group USER
    ./USER/: main.c Init.c Pid.c wdog.c
  group FUNC
    ./USER/: Mode.c LCD.c
    ./USER/FUNC/: ModeFunc.c LcdFunc.c ErrorFunc.c
  group DRIVER
    ./USER/: Key.c IC74HC165.c Adc.c Rtc.c E2prom.c Siic.c Uart.c Suart.c Uart485.c LCD_1621.c IC74HC595.c
  group WIFI
    ./USER/: Wifi.c
  group TUYA
    ./USER/TUYA/: mcu_api.c protocol.c system.c
  group INSIDELIB
    ./INSIDELIB/: sysclock.c sysdelay.c sysulib.c
